# Keil uVision project F407ZG_Template.uvprojx, settings and files
target F407ZG_Template (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F407ZG_Template +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Component\e2p;..\Component\oled;..\Component\sf_i2c;..\Component\UIcode;..\Component\TFT;..\Component\GUI;..\Component\GUI\lvgl_app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: delay.c main.c gpio.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group e2p
    ../Component/e2p/: at24cxx_i2c_port.c drv_at24cxx.c
  group sf_i2c
    ../Component/sf_i2c/: drv_i2c.c
  group TFT
    ../Component/TFT/: drv_lcd.c lcd_spi_port.c
  group lvgl_app
    ../Component/GUI/lvgl_app/: lvgl_app.c
  group lvgl_porting
    ../Component/GUI/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl_core
    ../Component/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../Component/GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl_extra
    ../Component/GUI/lvgl/src/extra/: lv_extra.c
    ../Component/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Component/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Component/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Component/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Component/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Component/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Component/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Component/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Component/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Component/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Component/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Component/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Component/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Component/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Component/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Component/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Component/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Component/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Component/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Component/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Component/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Component/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Component/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Component/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Component/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Component/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Component/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Component/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Component/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Component/GUI/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../Component/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_hal
    ../Component/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../Component/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../Component/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
software components: CMSIS:CORE 5.5.0
